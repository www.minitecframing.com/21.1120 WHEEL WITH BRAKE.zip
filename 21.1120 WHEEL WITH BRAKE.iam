# Autodesk Inventor assembly: 21.1120 WHEEL WITH BRAKE
## iProperties
Created: 2007-03
Part Number: 21.1120 WHEEL WITH BRAKE
Document SubType Name: Assembly
Designer: Andy Moles
Author: Andy Moles
